options:
  parameters:
    generate_options: qt_gui
    id: dl_tx_v1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ASM_BYTES
  id: variable
  parameters:
    comment: ASM = 0x1A CF FC 1D (4 bytes)
    value: len(ASM_MARKER)
  states: {}
- name: ASM_MARKER
  id: variable
  parameters:
    value: (0x1A, 0xCF, 0xFC, 0x1D)
  states: {}
- name: BITS_PER_FRAME
  id: variable
  parameters:
    value: BYTES_PER_FRAME*8
  states: {}
- name: BYTES_PER_FRAME
  id: variable
  parameters:
    value: '1115'
  states: {}
- name: BYTES_PER_TM_FRAME
  id: variable
  parameters:
    value: 223 * I_RS
  states: {}
- name: CADU_RS_ASM_BYTES
  id: variable
  parameters:
    value: RS_BYTES + ASM_BYTES
  states: {}
- name: DATA_RATE_BPS
  id: variable
  parameters:
    value: (Rs*k*(1/r))
  states: {}
- name: FILE_PATH
  id: variable
  parameters:
    value: '"/home/dogg/Downloads/tm_stagin_grc/qpsk/data/SPPencaps_CFDP_metadata_tx.bin"'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: I_RS
  id: variable
  parameters:
    comment: RS interleave depth (because 223 × 5 = 1115)
    value: '5'
  states: {}
- name: K
  id: variable
  parameters:
    value: '7'
  states: {}
- name: PACKET_ZONE_LEN
  id: variable
  parameters:
    value: TM_BODY_LEN - TM_SEC_HDR_LEN
  states: {}
- name: POST_CONV_BITS
  id: variable
  parameters:
    value: CADU_RS_ASM_BYTES *8*(1/r)
  states: {}
- name: POST_CONV_BYTES
  id: variable
  parameters:
    value: POST_CONV_BITS/8
  states: {}
- name: RAND_SEED_ALL_ONES
  id: variable
  parameters:
    value: '0x7FFF'
  states: {}
- name: RS_BYTES
  id: variable
  parameters:
    value: 255 * I_RS
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: Rs_0
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: TM_BODY_LEN
  id: variable
  parameters:
    value: BYTES_PER_TM_FRAME - TM_PRI_HDR_LEN
  states: {}
- name: TM_PRI_HDR_LEN
  id: variable
  parameters:
    value: '6'
  states: {}
- name: TM_SEC_HDR_LEN
  id: variable
  parameters:
    value: '12'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: beta
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: delay_Q
  id: variable
  parameters:
    value: sps/2
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: k
  id: variable
  parameters:
    value: '2'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: r
  id: variable
  parameters:
    value: 1/2
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_bw
  id: variable
  parameters:
    value: Rs*(1+beta)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,    Rs*sps,     Rs,    alpha,   span*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    alias: tm_out
    file: /home/dogg/Projects/CCSDS_OSI_APP_DL_PHYS_SIM/2_datalink_physical_sim_grc/qpsk/data/art/tm_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    alias: rs_out
    file: /home/dogg/Projects/CCSDS_OSI_APP_DL_PHYS_SIM/2_datalink_physical_sim_grc/qpsk/data/art/rs_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    alias: rand_out
    file: /home/dogg/Projects/CCSDS_OSI_APP_DL_PHYS_SIM/2_datalink_physical_sim_grc/qpsk/data/art/rand_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_2
  id: blocks_file_sink
  parameters:
    alias: conv_out
    file: /home/dogg/Projects/CCSDS_OSI_APP_DL_PHYS_SIM/2_datalink_physical_sim_grc/qpsk/data/art/conv_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    alias: asm_out
    file: /home/dogg/Projects/CCSDS_OSI_APP_DL_PHYS_SIM/2_datalink_physical_sim_grc/qpsk/data/art/asm_out.bin
    type: byte
  states: {}
- name: blocks_tagged_stream_align_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np, time\nfrom collections import deque\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    CCSDS TM Framer (Primary+optional 12B Secondary Header, Segmentation, FHP).\n      In : bytes (uchar) tagged stream, 'packet_len' = SPP length\n      Out: bytes (uchar) fixed-size TM frames: H(6) + B(TM_BODY_LEN)\n           Each frame tagged with 'packet_len' = 6 + TM_BODY_LEN\n    Notes:\n      - TM_BODY_LEN is the ENTIRE data field length (what RS sees).\n      - If Sec_Hdr_Flag=1, the first S bytes of the data field are the Secondary Header.\n      - FHP counts from the start of the Packet Zone (immediately after the SecHdr).\n    \"\"\"\n\n    def __init__(self,\n                 len_tag_key=\"packet_len\",\n                 tm_hdr_len=6,\n                 tm_body_len=1115,      # full data field length (SecHdr + Packet Zone)\n                 scid=0x042, vcid=0,\n                 sec_hdr_flag=0,\n                 sec_hdr_len=12,        # 12-byte secondary header\n                 ocf_present=0,\n                 sync_flag=0,\n                 pkt_order_flag=0,\n                 sl_id=1,               # 01b => Packet TM with FHP\n                 fill_byte=0x00):\n        gr.sync_block.__init__(self,\n            name=\"tm_framer_seg\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8])\n\n        # lengths\n        self.H  = int(tm_hdr_len)\n        assert self.H == 6, \"This emits a 6-byte primary header.\"\n        self.B  = int(tm_body_len)          # full TM data field\n        self.SF = 1 if sec_hdr_flag else 0\n        self.S  = int(sec_hdr_len) if self.SF else 0   # secondary header size\n        assert self.B > self.S, \"TM_BODY_LEN must exceed Secondary Header length\"\n        self.PZ = self.B - self.S           # bytes available for Space Packets\n        self.F  = self.H + self.B           # total bytes per frame\n        self.set_output_multiple(self.F)    # only produce whole frames\n\n        # fields / flags\n        self.scid  = int(scid)   & 0x3FF\n        self.vcid  = int(vcid)   & 0x7\n        self.sec   = self.SF     # primary-header SecHdrFlag reflects reality\n        self.ocf   = 1 if ocf_present else 0\n        self.sync  = 1 if sync_flag else 0\n        self.pord  = 1 if pkt_order_flag else 0\n        self.sl_id = int(sl_id) & 0x3\n\n        # counters (roll at 256)\n        self.mcfc  = 0\n        self.vcfc  = 0\n\n        # plumbing\n        self.len_key   = pmt.intern(str(len_tag_key))\n        self.fill_byte = int(fill_byte) & 0xFF\n\n        # SPP assembly state\n        self._open_chunk = None\n        self.spp_q = deque()\n        self._carry = None  # continuation across frames: {'data': bytes, 'pos': int}\n\n    # ---------- helpers ----------\n    def _build_tm_primary(self, fhp):\n        # Word 1: ver(2)=00, SCID(10), VCID(3), OCF(1)\n        w1 = (0 << 14) | (self.scid << 4) | (self.vcid << 1) | (self.ocf & 0x1)\n        # Word 2: MCFC(8) VCFC(8)\n        w2 = ((self.mcfc & 0xFF) << 8) | (self.vcfc & 0xFF)\n        # Word 3: SecHdr(1) Sync(1) PktOrd(1) SLID(2) FHP(11)\n        fhp &= 0x7FF\n        w3 = ((self.sec & 1) << 15) | ((self.sync & 1) << 14) | ((self.pord & 1) << 13) \\\n             | ((self.sl_id & 0x3) << 11) | fhp\n        hdr = bytearray(6)\n        hdr[0]=(w1>>8)&0xFF; hdr[1]=w1&0xFF\n        hdr[2]=(w2>>8)&0xFF; hdr[3]=w2&0xFF\n        hdr[4]=(w3>>8)&0xFF; hdr[5]=w3&0xFF\n        return hdr\n\n    def _build_secondary_header(self):\n        \"\"\"\n        12-byte Secondary Header:\n          [0]  SH_Version(2b)=00 | SH_ID(6b)=0x00\n          [1]  Flags (spare for now, set 0)\n          [2..8]  CUC time: coarse(4 bytes, seconds since UNIX epoch), fine(3 bytes, 1/2^24 s)\n          [9..11] User bytes (0 for now)\n        \"\"\"\n        sh = bytearray(self.S if self.S else 0)\n        if not self.S: return sh\n        # Byte 0: version+id (both zero for now)\n        sh[0] = 0x00\n        sh[1] = 0x00\n        # Time\n        now = time.time()\n        coarse = int(now) & 0xFFFFFFFF\n        fine   = int((now - int(now)) * (1<<24)) & 0xFFFFFF  # 3 bytes\n        sh[2] = (coarse >> 24) & 0xFF\n        sh[3] = (coarse >> 16) & 0xFF\n        sh[4] = (coarse >> 8)  & 0xFF\n        sh[5] = coarse & 0xFF\n        sh[6] = (fine >> 16) & 0xFF\n        sh[7] = (fine >> 8)  & 0xFF\n        sh[8] = fine & 0xFF\n        # user bytes\n        for i in range(9, 12):\n            sh[i] = 0x00\n        return sh\n\n    def _emit_frame(self, out, out_off, fhp, payload_bytes, sec_hdr_bytes=None):\n        # Primary\n        ph = self._build_tm_primary(fhp)\n        out[out_off:out_off+self.H] = np.frombuffer(ph, dtype=np.uint8)\n        # Secondary (if present) goes at the head of the data field\n        pos = out_off + self.H\n        if self.S:\n            sh = sec_hdr_bytes if sec_hdr_bytes is not None else self._build_secondary_header()\n            out[pos:pos+self.S] = np.frombuffer(sh, dtype=np.uint8)\n            pos += self.S\n        # Packet Zone payload (length self.PZ) follows\n        out[pos:pos+self.PZ] = np.frombuffer(payload_bytes, dtype=np.uint8)\n\n        # counters\n        self.mcfc = (self.mcfc + 1) & 0xFF\n        self.vcfc = (self.vcfc + 1) & 0xFF\n\n        # length tag at frame start (whole frame length)\n        self.add_item_tag(0, self.nitems_written(0) + out_off, self.len_key, pmt.from_long(self.F))\n\n    # ---------- work ----------\n    def work(self, input_items, output_items):\n        inn, out = input_items[0], output_items[0]\n        n_in, n_out = len(inn), len(out)\n\n        # 1) Ingest SPPs via packet_len tags\n        if n_in:\n            start = self.nitems_read(0); end = start + n_in\n            tags = self.get_tags_in_range(0, start, end, self.len_key)\n            tags.sort(key=lambda t: int(t.offset))\n            abs_pos = start; consumed = 0; ti = 0\n\n            def copy_span(a, b):\n                nonlocal consumed\n                if b <= a: return\n                chunk = bytes(inn[(a-start):(b-start)])\n                if self._open_chunk is not None:\n                    self._open_chunk['data'] += chunk\n                    self._open_chunk['need'] -= (b - a)\n                    if self._open_chunk['need'] <= 0:\n                        self.spp_q.append(self._open_chunk['data'])\n                        self._open_chunk = None\n                consumed += (b - a)\n\n            while abs_pos < end:\n                if self._open_chunk is None:\n                    if ti >= len(tags):\n                        consumed += (end - abs_pos); abs_pos = end; break\n                    tag = tags[ti]; tag_off = int(tag.offset)\n                    tag_len = int(pmt.to_long(tag.value))\n                    if tag_off > abs_pos:\n                        copy_span(abs_pos, tag_off); abs_pos = tag_off; continue\n                    self._open_chunk = {'start': tag_off, 'need': tag_len, 'data': bytearray()}\n                    ti += 1\n                # fill current chunk\n                need = self._open_chunk['need']\n                avail = end - abs_pos\n                take = min(avail, need)\n                copy_span(abs_pos, abs_pos + take)\n                abs_pos += take\n\n            self.consume(0, consumed)\n\n        # 2) Build frames (only in whole-frame multiples)\n        produced = 0; out_off = 0\n        while (n_out - out_off) >= self.F:\n            # Prepare Packet Zone buffer (size self.PZ)\n            pz = bytearray([self.fill_byte] * self.PZ)\n\n            fhp = 0x7FF\n            idx = 0\n\n            # 2a) Continue previous SPP if any\n            if self._carry is not None:\n                tail = self._carry\n                take = min(self.PZ - idx, len(tail['data']) - tail['pos'])\n                pz[idx:idx+take] = tail['data'][tail['pos']:tail['pos']+take]\n                tail['pos'] += take; idx += take\n                if tail['pos'] >= len(tail['data']):\n                    self._carry = None\n                    if idx < self.PZ and len(self.spp_q) > 0:\n                        fhp = idx  # first new SPP header starts at this offset in the Packet Zone\n\n            # 2b) Pull whole SPPs\n            while idx < self.PZ and len(self.spp_q) > 0:\n                pkt = self.spp_q[0]\n                if fhp == 0x7FF:\n                    fhp = 0 if (idx == 0 and self._carry is None) else idx\n                if len(pkt) <= (self.PZ - idx):\n                    pz[idx:idx+len(pkt)] = pkt\n                    idx += len(pkt)\n                    self.spp_q.popleft()\n                else:\n                    take = self.PZ - idx\n                    pz[idx:idx+take] = pkt[:take]\n                    self._carry = {'data': pkt, 'pos': take}\n                    self.spp_q.popleft()\n                    idx += take\n                    break\n\n            # Emit frame (Secondary Header is injected inside)\n            self._emit_frame(out, out_off, fhp, pz)\n            out_off += self.F; produced += self.F\n\n        return produced\n\n"
    alias: tm_framer
    fill_byte: '0x00'
    len_tag_key: '"packet_len"'
    ocf_present: '0'
    pkt_order_flag: '0'
    scid: '0x42'
    sec_hdr_flag: '1'
    sec_hdr_len: TM_SEC_HDR_LEN
    sl_id: '1'
    sync_flag: '0'
    tm_body_len: TM_BODY_LEN
    tm_hdr_len: TM_PRI_HDR_LEN
    vcid: '0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.basic_block):\n    \"\"\"\n    CCSDS TM Randomizer / De-randomizer (robust, frame-tag driven).\n\n    - PN polynomial: x^15 + x^14 + 1 (CCSDS)\n    - Seed: 0x7FFF (all ones), reseeded at each frame start (by default)\n    - Frame boundaries are given by a length tag (e.g., \"packet_len\"), whose value is the *byte length* of the frame\n      produced by your TM framer (i.e., TM primary header + TM data field).\n    - Tag-safe: forwards all input tags to output with corrected offsets.\n\n    Parameters\n    ----------\n    len_tag_key : str\n        Name of the length tag carrying the frame length (default: \"packet_len\").\n    seed : int\n        15-bit initial seed (default 0x7FFF per CCSDS).\n    restart_per_frame : bool\n        If True, reseed PN at each frame start (default True).\n    enabled : bool\n        If False, pass-through (still forwards tags; default True).\n    mode : str\n        One of {\"frame\",\"data_field\",\"packet_zone\"}:\n          - \"frame\"       : randomize entire TM frame (header + data field).\n          - \"data_field\"  : skip 6-byte TM primary header; randomize only TM data field.\n          - \"packet_zone\" : skip 6-byte TM primary header + 'sec_hdr_len' bytes; randomize only packet zone.\n    sec_hdr_len : int\n        Length of TM Secondary Header (bytes) if using \"packet_zone\" mode (default 0).\n        Ignored in other modes.\n    pri_hdr_len : int\n        Primary header length (bytes). For CCSDS TM this is 6. (Default 6)\n    max_tag_per_window : int\n        Guardrail to avoid pathological cases (default 1024).\n\n    Notes\n    -----\n    - XOR randomization is symmetric; the same block de-randomizes.\n    - This block assumes that *each* frame is tagged exactly once at its *first byte* with len_tag_key.\n    - If multiple frames appear within one scheduler call, all are handled.\n    \"\"\"\n\n    def __init__(self,\n                 len_tag_key=\"packet_len\",\n                 seed=0x7FFF,\n                 restart_per_frame=True,\n                 enabled=True,\n                 mode=\"frame\",\n                 sec_hdr_len=0,\n                 pri_hdr_len=6,\n                 max_tag_per_window=1024):\n\n        gr.basic_block.__init__(self,\n            name=\"ccsds_tm_randomizer_v2\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8]\n        )\n\n        # ---- Params\n        self.len_tag_key_str = str(len_tag_key)\n        self.len_tag_key = pmt.intern(self.len_tag_key_str)\n\n        self.seed = int(seed) & 0x7FFF\n        if self.seed == 0:\n            # 15-bit LFSR cannot be zero; force to CCSDS default\n            self.seed = 0x7FFF\n\n        self.restart_per_frame = bool(restart_per_frame)\n        self.enabled = bool(enabled)\n\n        self.mode = str(mode).lower()\n        if self.mode not in (\"frame\", \"data_field\", \"packet_zone\"):\n            raise ValueError(\"mode must be 'frame', 'data_field', or 'packet_zone'.\")\n\n        self.sec_hdr_len = max(0, int(sec_hdr_len))\n        self.pri_hdr_len = max(0, int(pri_hdr_len))\n        self.max_tag_per_window = int(max_tag_per_window)\n\n        # ---- State\n        self._lfsr = self.seed\n        self._frame_bytes_left = 0   # remaining bytes to randomize in *this frame*\n        self._skip_left = 0          # per-frame leading bytes to skip (per mode)\n        self._abs_out = 0            # optional counter\n\n        # Stats (optional)\n        self.frames_seen = 0\n        self.frames_rand = 0\n        self.frames_skipped = 0\n\n    # ---- PN generator (CCSDS 15-bit LFSR)\n    @staticmethod\n    def _step_lfsr(state):\n        # feedback from bit14 ^ bit13 (1-indexed x^15 + x^14 + 1)\n        new_bit = ((state >> 14) ^ (state >> 13)) & 0x1\n        return ((state << 1) & 0x7FFF) | new_bit\n\n    def _pn_bytes(self, n):\n        \"\"\"\n        Generate 'n' PN bytes from current LFSR state (MSB-first).\n        Vectorized for fewer Python-level loops.\n        \"\"\"\n        out = np.empty(n, dtype=np.uint8)\n        s = self._lfsr\n        for i in range(n):\n            b = 0\n            # Unroll 8 bit-steps into one byte\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            b = (b << 1) | ((s >> 14) & 1); s = self._step_lfsr(s)\n            out[i] = b\n        self._lfsr = s\n        return out\n\n    def _reset_pn(self):\n        self._lfsr = self.seed\n\n    # ---- Tag forwarding (preserve all tags, not just length)\n    def _forward_tags(self, n_input, produced):\n        in0 = 0\n        nread = self.nitems_read(in0)\n        nwrite = self.nitems_written(in0)\n\n        abs_start = nread\n        abs_end   = nread + n_input\n\n        tags = self.get_tags_in_range(in0, abs_start, abs_end)\n        # guard against pathological cases\n        if len(tags) > self.max_tag_per_window:\n            tags = tags[:self.max_tag_per_window]\n\n        for t in tags:\n            rel = int(t.offset - nread)  # 0..n_input-1\n            if rel < 0 or rel >= n_input:\n                continue\n            out_off = nwrite + produced + rel\n            try:\n                self.add_item_tag(in0, out_off, t.key, t.value, t.srcid)\n            except TypeError:\n                self.add_item_tag(in0, out_off, t.key, t.value)\n\n    # ---- Consume only (start_offset, frame_len) for our length-tag key\n    def _find_frame_starts(self, n_input):\n        in0 = 0\n        nread = self.nitems_read(in0)\n        abs_start = nread\n        abs_end   = nread + n_input\n\n        tags = self.get_tags_in_range(in0, abs_start, abs_end, self.len_tag_key)\n        if not tags:\n            return []\n\n        items = []\n        for t in tags:\n            try:\n                L = int(pmt.to_long(t.value))\n            except Exception:\n                continue\n            if L <= 0:\n                continue\n            rel = int(t.offset - nread)\n            if rel < 0 or rel >= n_input:\n                continue\n            items.append((rel, L))\n\n        if not items:\n            return []\n\n        # sort and dedup by rel offset (ignore any overlapping/duplicate starts)\n        items.sort(key=lambda x: x[0])\n        dedup = []\n        last_rel = None\n        for rel, L in items:\n            if rel != last_rel:\n                dedup.append((rel, L))\n                last_rel = rel\n\n        return dedup[:self.max_tag_per_window]\n\n    # ---- Compute per-frame skip (based on mode)\n    def _compute_skip(self):\n        if self.mode == \"frame\":\n            return 0\n        elif self.mode == \"data_field\":\n            return self.pri_hdr_len\n        elif self.mode == \"packet_zone\":\n            return self.pri_hdr_len + self.sec_hdr_len\n        else:\n            return 0\n\n    # ---- Core\n    def general_work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_in  = len(inp)\n        n_out = len(out)\n        if n_in == 0 or n_out == 0:\n            return 0\n\n        produced = 0\n        consumed = 0\n        cursor   = 0\n\n        # Forward *all* input tags seen in this window\n        self._forward_tags(n_in, produced=0)\n\n        # Find any frame starts in this window for our len_tag_key\n        starts = self._find_frame_starts(n_in)\n        si = 0\n\n        # Local helper: process N input bytes from current cursor\n        def process_bytes(nbytes):\n            nonlocal produced, consumed, cursor\n\n            if nbytes <= 0:\n                return\n            n = min(nbytes, n_out - produced)\n            if n <= 0:\n                return\n\n            if not self.enabled:\n                # bypass\n                out[produced:produced+n] = inp[cursor:cursor+n]\n                produced += n\n                consumed += n\n                cursor   += n\n                return\n\n            # Apply per-frame skip first\n            if self._skip_left > 0:\n                s = min(self._skip_left, n)\n                # pass-through the skipped leading bytes\n                out[produced:produced+s] = inp[cursor:cursor+s]\n                self._skip_left -= s\n                produced += s\n                consumed += s\n                cursor   += s\n                n -= s\n                if n == 0:\n                    return  # all consumed from this call\n\n            if self._frame_bytes_left > 0 and n > 0:\n                to_rand = min(n, self._frame_bytes_left)\n                # XOR with PN\n                pn = self._pn_bytes(to_rand)\n                out[produced:produced+to_rand] = np.bitwise_xor(inp[cursor:cursor+to_rand], pn)\n\n                produced += to_rand\n                consumed += to_rand\n                cursor   += to_rand\n                self._frame_bytes_left -= to_rand\n                n -= to_rand\n\n            # Any trailing bytes beyond frame boundary are pass-through\n            if n > 0:\n                out[produced:produced+n] = inp[cursor:cursor+n]\n                produced += n\n                consumed += n\n                cursor   += n\n\n        # Walk frames that start within this scheduler window\n        while si < len(starts):\n            rel_off, frame_len = starts[si]\n            # bytes before the frame start (from current cursor)\n            pre = rel_off - cursor\n            if pre > 0:\n                process_bytes(pre)\n                if produced >= n_out:\n                    break\n\n            # Start of a new frame at current cursor\n            if self.restart_per_frame:\n                self._reset_pn()\n            self._frame_bytes_left = int(frame_len)\n            self._skip_left = self._compute_skip()\n\n            self.frames_seen += 1\n            if self._frame_bytes_left > 0:\n                self.frames_rand += 1\n\n            si += 1\n\n        # After walking all starts, process whatever input remains in this window\n        if produced < n_out and cursor < n_in:\n            process_bytes(n_in - cursor)\n\n        self._abs_out += produced\n        self.consume(0, consumed)\n        return produced\n\n"
    alias: tm_rand
    enabled: 'True'
    len_tag_key: '"packet_len"'
    max_tag_per_window: '1024'
    mode: '"frame"'
    pri_hdr_len: TM_PRI_HDR_LEN
    restart_per_frame: 'True'
    sec_hdr_len: TM_SEC_HDR_LEN
    seed: RAND_SEED_ALL_ONES
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\"\"\"\nASM Inserter with Monitor Tap (CCSDS CADU builder)\n\nIn  : uint8 bytes (RS-coded frames, default 1275 B), arbitrarily chunked.\nOut0: uint8 bytes  -> CADU stream (ASM 4B + RS 1275B = 1279B)  [to conv encoder]\nOut1: float32      -> Mirror of Out0 converted to floats        [to Len Meter -> Number Sink]\n\nBehavior:\n- Drops ALL upstream tags (TPP_DONT).\n- Emits exactly one length tag per CADU on BOTH outputs (default key \"packet_len\" = 1279).\n- Buffers partial input and outputs CADUs as soon as RS_LEN bytes are available.\n\nParams:\n- len_tag_key : downstream length tag key (default \"packet_len\")\n- rs_len      : RS-coded length per frame (default 1275; for I=5 interleave)\n- asm_hex     : 8 hex chars, big-endian ASM (default \"1ACFFC1D\")\n- enable_sanity : if True, prints a one-liner when dropping upstream tags\n\"\"\"\n\nimport sys\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self,\n                 len_tag_key=\"packet_len\",\n                 rs_len=1275,\n                 asm_hex=\"1ACFFC1D\",\n                 enable_sanity=True):\n        gr.sync_block.__init__(\n            self,\n            name=\"ccsds_asm_inserter_tapped\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8, np.float32],   # Out[0]=bytes (main), Out[1]=float (monitor)\n        )\n\n        # --- Params ---\n        self.len_tag_key = str(len_tag_key)\n        self.len_key_sym = pmt.intern(self.len_tag_key)\n        self.RS_LEN = int(rs_len)\n        self.enable_sanity = bool(enable_sanity)\n\n        if not (isinstance(asm_hex, str) and len(asm_hex) == 8):\n            raise ValueError(\"asm_hex must be 8 hex chars, e.g., '1ACFFC1D'\")\n        try:\n            asm_val = int(asm_hex, 16)\n        except ValueError:\n            raise ValueError(\"asm_hex must be valid hex, e.g., '1ACFFC1D'\")\n        self.ASM = asm_val.to_bytes(4, byteorder=\"big\")\n        self.CADU_LEN = 4 + self.RS_LEN  # 1279 by default\n\n        # --- State ---\n        self._inbuf = bytearray()\n        self._outbuf = bytearray()\n        self._pending = []          # queue of CADU sizes waiting to tag/emit\n        self._head_remaining = 0    # bytes remaining in current CADU emission\n\n        # Do NOT forward upstream tags; we add our own clean frame tags.\n        self.set_tag_propagation_policy(gr.TPP_DONT)\n\n    # Optional: observe & drop upstream tags (never forwarded)\n    def _maybe_warn_upstream_tags(self, ninput_items):\n        if not self.enable_sanity:\n            return\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n        if tags:\n            try:\n                sys.stderr.write(\"[asm_inserter] Dropping {} upstream tags (by design).\\n\".format(len(tags)))\n            except Exception:\n                pass\n\n    # Build as many CADUs as possible\n    def _consume_to_cadus(self):\n        while len(self._inbuf) >= self.RS_LEN:\n            payload = bytes(self._inbuf[:self.RS_LEN])\n            del self._inbuf[:self.RS_LEN]\n            cadu = self.ASM + payload\n            self._outbuf += cadu\n            self._pending.append(self.CADU_LEN)\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        y0 = output_items[0]  # bytes (main path)\n        y1 = output_items[1]  # float (monitor tap)\n\n        n_in = len(x)\n        if n_in:\n            self._inbuf += bytes(x)\n            self._maybe_warn_upstream_tags(n_in)\n            self._consume_to_cadus()\n\n        if not self._outbuf:\n            self.consume_each(n_in)\n            return 0  # nothing ready yet\n\n        space0 = len(y0)\n        space1 = len(y1)\n        space = min(space0, space1)  # sync_block must produce same on all outs\n        if space == 0:\n            self.consume_each(n_in)\n            return 0\n\n        produced = 0\n        ow0 = self.nitems_written(0)\n        ow1 = self.nitems_written(1)\n\n        while space > 0 and self._outbuf:\n            # Start-of-frame: set remaining and emit tags on BOTH outputs\n            if self._head_remaining == 0:\n                if not self._pending:\n                    break\n                self._head_remaining = self._pending[0]\n                # tag at current write offset on both outputs\n                self.add_item_tag(0, ow0 + produced, self.len_key_sym, pmt.from_long(self.CADU_LEN))\n                self.add_item_tag(1, ow1 + produced, self.len_key_sym, pmt.from_long(self.CADU_LEN))\n\n            # Max chunk we can emit now\n            chunk = min(space, self._head_remaining, len(self._outbuf))\n            if chunk <= 0:\n                break\n\n            # Copy bytes to out0\n            y0[produced:produced+chunk] = np.frombuffer(self._outbuf[:chunk], dtype=np.uint8)\n            # Convert to float for out1 (0..255 as float)\n            # Avoid extra allocation: simple vectorized cast\n            y1[produced:produced+chunk] = np.frombuffer(self._outbuf[:chunk], dtype=np.uint8).astype(np.float32)\n\n            del self._outbuf[:chunk]\n            produced += chunk\n            space -= chunk\n            self._head_remaining -= chunk\n\n            if self._head_remaining == 0 and self._pending:\n                self._pending.pop(0)\n\n        self.consume_each(n_in)\n        return produced\n\n"
    alias: asm_ins
    asm_hex: '"1ACFFC1D"'
    enable_sanity: 'True'
    len_tag_key: '"packet_len"'
    rs_len: '1275'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    K: K
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\"\"\"\nccsds_conv_k7_r12_epy_sync — Convolutional encoder (K=7, r=1/2) matched to Viterbi\n\nInput : uint8 BYTES (packed; 8 bits/byte), framed by 'packet_len' = input BYTES (e.g., 1279)\nOutput: uint8 BYTES (packed), framed by 'packet_len' = 2*input BYTES (e.g., 2558)\n\nToggles (must agree with Viterbi):\n- g2_inverted   : invert the G2 output bit (False to match your current RX; True for CCSDS base flavor)\n- c1c2_order    : multiplex order of encoder outputs; True => C1 then C2, False => C2 then C1\n- msb_first     : bit packing inside each byte\n- reset_each_frame : reset state to 0 for each tagged frame (set False for continuous trellis)\n- strict_frame_len_in : if >0, force this input frame length; ignore incoming tag values\n\nNotes:\n- No tail bits are added; pure streaming per frame.\n- Emits exactly one clean length tag at the first output byte of each encoded frame.\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    def __init__(self,\n                 len_tag_key=\"packet_len\",\n                 K=7,\n                 gen0=0o171,            # C1\n                 gen1=0o133,            # C2\n                 msb_first=True,\n                 reset_each_frame=True,\n                 g2_inverted=False,\n                 c1c2_order=True,\n                 strict_frame_len_in=1279):\n        gr.sync_block.__init__(\n            self,\n            name=\"ccsds_conv_k7_r12_epy_sync\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8],\n        )\n        # Params\n        self.len_tag_key = str(len_tag_key)\n        self.len_key_sym = pmt.intern(self.len_tag_key)\n        self.K = int(K)\n        self.gen0 = np.uint32(int(gen0))\n        self.gen1 = np.uint32(int(gen1))\n        self._mask = np.uint32((1 << self.K) - 1)\n        self.msb_first = bool(msb_first)\n        self.reset_each_frame = bool(reset_each_frame)\n        self.g2_inverted = bool(g2_inverted)\n        self.c1c2_order = bool(c1c2_order)\n        self.strict_frame_len_in = int(strict_frame_len_in)\n\n        # State\n        self._inbuf = bytearray()\n        self._frame_queue = []       # pending input frame lengths (bytes)\n        self._state = np.uint32(0)   # shift register\n\n        self._outbuf = bytearray()\n        self._pending_out_frames = []  # encoded frame lengths to tag\n        self._head_remaining = 0\n\n        # We emit our own clean length tags\n        self.set_tag_propagation_policy(gr.TPP_DONT)\n\n    # ---------- helpers ----------\n    @staticmethod\n    def _parity_u32(x: int) -> int:\n        # bit-parity (XOR popcount)\n        v = x\n        v ^= (v >> 16)\n        v ^= (v >> 8)\n        v ^= (v >> 4)\n        v &= 0xF\n        # 0x6996 parity lookup for 4 bits\n        return (0x6996 >> v) & 1\n\n    def _bytes_to_bits(self, b: bytes) -> np.ndarray:\n        a = np.frombuffer(b, dtype=np.uint8)\n        if self.msb_first:\n            shifts = np.array([7,6,5,4,3,2,1,0], dtype=np.uint8)\n        else:\n            shifts = np.array([0,1,2,3,4,5,6,7], dtype=np.uint8)\n        return ((a[:, None] >> shifts[None, :]) & 1).astype(np.uint8).reshape(-1)\n\n    def _bits_to_bytes(self, bits: np.ndarray) -> bytes:\n        n = bits.size\n        pad = (8 - (n % 8)) % 8\n        if pad:\n            bits = np.concatenate([bits, np.zeros(pad, dtype=np.uint8)])\n        bits = bits.reshape(-1, 8)\n        if self.msb_first:\n            weights = (1 << np.array([7,6,5,4,3,2,1,0], dtype=np.uint8)).astype(np.uint16)\n        else:\n            weights = (1 << np.array([0,1,2,3,4,5,6,7], dtype=np.uint8)).astype(np.uint16)\n        packed = (bits * weights).sum(axis=1).astype(np.uint8)\n        return bytes(packed)\n\n    def _encode_bits(self, in_bits: np.ndarray) -> np.ndarray:\n        n = in_bits.size\n        out = np.empty(n * 2, dtype=np.uint8)\n        state = self._state\n        mask = self._mask\n        g0 = self.gen0\n        g1 = self.gen1\n\n        idx = 0\n        if self.c1c2_order:\n            # C1 then C2\n            for b in in_bits:\n                state = ((state << np.uint32(1)) | np.uint32(int(b & 1))) & mask\n                c1 = self._parity_u32(int(state & g0))\n                c2 = self._parity_u32(int(state & g1)) ^ (1 if self.g2_inverted else 0)\n                out[idx]   = c1\n                out[idx+1] = c2\n                idx += 2\n        else:\n            # C2 then C1\n            for b in in_bits:\n                state = ((state << np.uint32(1)) | np.uint32(int(b & 1))) & mask\n                c1 = self._parity_u32(int(state & g0))\n                c2 = self._parity_u32(int(state & g1)) ^ (1 if self.g2_inverted else 0)\n                out[idx]   = c2\n                out[idx+1] = c1\n                idx += 2\n\n        # update/clear state\n        if self.reset_each_frame:\n            self._state = np.uint32(0)\n        else:\n            self._state = state\n        return out\n\n    # ---------- input frame parsing ----------\n    def _enqueue_len_tags(self, ninput_items: int):\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n        for t in tags:\n            try:\n                key_str = pmt.symbol_to_string(t.key)\n            except Exception:\n                continue\n            if key_str == self.len_tag_key and pmt.is_integer(t.value):\n                L = int(pmt.to_long(t.value))\n                if self.strict_frame_len_in > 0:\n                    L = self.strict_frame_len_in\n                if L > 0:\n                    self._frame_queue.append(L)\n\n    def _process_frames_to_outbuf(self):\n        # Convert as many full input frames as are currently buffered\n        while self._frame_queue:\n            need = self._frame_queue[0]\n            if len(self._inbuf) < need:\n                break\n            inp = bytes(self._inbuf[:need])\n            del self._inbuf[:need]\n            self._frame_queue.pop(0)\n\n            bits_in  = self._bytes_to_bits(inp)\n            bits_out = self._encode_bits(bits_in)\n            enc      = self._bits_to_bytes(bits_out)  # exactly 2*need bytes\n\n            self._outbuf += enc\n            self._pending_out_frames.append(len(enc))  # schedule tag on write\n\n    # ---------- work ----------\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n\n        n_in = len(in0)\n        if n_in:\n            self._inbuf += bytes(in0)\n            self._enqueue_len_tags(n_in)\n            self._process_frames_to_outbuf()\n\n        if not self._outbuf:\n            self.consume_each(n_in)\n            return 0\n\n        ow = self.nitems_written(0)\n        space = len(out0)\n        produced = 0\n\n        while space > 0 and self._outbuf:\n            if self._head_remaining == 0:\n                if not self._pending_out_frames:\n                    break\n                self._head_remaining = self._pending_out_frames[0]\n                # tag *start* of this encoded frame on output\n                self.add_item_tag(0, ow + produced, self.len_key_sym, pmt.from_long(self._head_remaining))\n\n            chunk = min(space, self._head_remaining, len(self._outbuf))\n            if chunk <= 0:\n                break\n\n            out0[produced:produced+chunk] = np.frombuffer(self._outbuf[:chunk], dtype=np.uint8)\n            del self._outbuf[:chunk]\n\n            produced += chunk\n            space    -= chunk\n            self._head_remaining -= chunk\n\n            if self._head_remaining == 0 and self._pending_out_frames:\n                self._pending_out_frames.pop(0)\n\n        self.consume_each(n_in)\n        return produced\n\n"
    alias: conv_k7r12
    c1c2_order: 'True'
    g2_inverted: 'False'
    gen0: 0o171
    gen1: 0o133
    len_tag_key: '"packet_len"'
    msb_first: 'True'
    reset_each_frame: 'True'
    strict_frame_len_in: '1279'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    I: I_RS
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\"\"\"\nCCSDS RS(255,223) encoder + symbol interleaver (depth I), TX side.\n\nIn  : BYTES (uint8) tagged stream, len_tag_key = 223*I (already randomized)\nOut0: BYTES (uint8) tagged stream, len_tag_key = 255*I (I interleaved RS codewords)\nOut1: FLOAT (float32) tap (same item count as Out0) for plotting/probing\n\nInterleaver: de-mux 223*I → I branches of 223 (round-robin), RS(255,223) each,\n             then symbol-interleave column-wise: cw0[0],cw1[0],...,cw{I-1}[0],cw0[1],...\n\"\"\"\n\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, len_tag_key=\"packet_len\", I=5, tm_len=1115):\n        gr.basic_block.__init__(\n            self,\n            name=\"rs255_223_encode_interleave_I\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8, np.float32],   # ✅ stream outputs as dtypes\n        )\n\n        # ---- Params ----\n        self.len_key = pmt.intern(str(len_tag_key))\n        self.I = int(I)\n        self.tm_len = int(tm_len)  # must be 223*I\n\n        # ---- RS(255,223) constants ----\n        self.N  = 255\n        self.K  = 223\n        self.NP = self.N - self.K  # 32 parity bytes\n\n        if self.tm_len != self.K * self.I:\n            raise ValueError(f\"tm_len ({self.tm_len}) must equal 223*I ({self.K*self.I})\")\n\n        # ---- GF(256) tables, primitive poly 0x11D ----\n        self._gf_init(prim=0x11D)\n        # g(x) = ∏_{i=1..32} (x − α^i)\n        self.gen = self._rs_generator(self.NP)\n\n        # forward non-length tags from input to output frame head\n        self._forward_all_tags = True\n\n    # ---------------- GF(256) helpers ----------------\n    def _gf_init(self, prim=0x11D):\n        self.gf_exp = np.zeros(512, dtype=np.uint8)\n        self.gf_log = np.full(256, -1, dtype=np.int16)\n        x = 1\n        for i in range(255):\n            self.gf_exp[i] = x\n            self.gf_log[x] = i\n            x <<= 1\n            if x & 0x100:\n                x ^= prim\n        # duplicate for fast wrap\n        self.gf_exp[255:510] = self.gf_exp[:255]\n        self.gf_exp[510:]    = self.gf_exp[:2]\n\n    @staticmethod\n    def _gf_add(a, b):  # = subtract\n        return a ^ b\n\n    def _gf_mul(self, a, b):\n        if a == 0 or b == 0:\n            return 0\n        return int(self.gf_exp[int(self.gf_log[a]) + int(self.gf_log[b])])\n\n    def _poly_mul(self, p, q):\n        r = np.zeros(len(p) + len(q) - 1, dtype=np.uint8)\n        for i, a in enumerate(p):\n            if a == 0: continue\n            ai = int(a)\n            for j, b in enumerate(q):\n                if b == 0: continue\n                r[i + j] ^= self._gf_mul(ai, int(b))\n        return r\n\n    def _rs_generator(self, nsym):\n        g = np.array([1], dtype=np.uint8)\n        for i in range(1, nsym + 1):\n            g = self._poly_mul(g, np.array([1, self.gf_exp[i]], dtype=np.uint8))\n        return g  # length nsym+1\n\n    def _rs_encode_223_255(self, data):\n        \"\"\"Return 32-byte parity for a 223-byte message (systematic RS).\"\"\"\n        if len(data) != self.K:\n            raise ValueError(\"RS encoder expects exactly 223 data bytes\")\n        rem = np.zeros(self.NP, dtype=np.uint8)\n        # LFSR-style division: remainder of x^NP * data(x) by g(x)\n        for d in data:\n            coef = d ^ rem[0]\n            rem = np.concatenate([rem[1:], np.array([0], dtype=np.uint8)])\n            if coef != 0:\n                for j in range(self.NP):\n                    rem[j] ^= self._gf_mul(int(self.gen[j + 1]), int(coef))\n        return bytes(rem)  # 32B parity\n\n    # ----------------- Helpers -----------------\n    def _demux_round_robin(self, tm_bytes):\n        \"\"\"Split 223*I into I branches of 223 bytes: j, j+I, j+2I, ...\"\"\"\n        branches = []\n        for j in range(self.I):\n            branch = tm_bytes[j::self.I]\n            if len(branch) != self.K:\n                branch = np.pad(branch, (0, self.K - len(branch)), constant_values=0)\n            branches.append(np.array(branch, dtype=np.uint8))\n        return branches\n\n    def _interleave_symbols(self, codewords):\n        \"\"\"codewords: list of I arrays (len 255). Output: cw0[0],cw1[0],...,cw{I-1}[0], cw0[1],...\"\"\"\n        out = np.empty(self.N * self.I, dtype=np.uint8)\n        idx = 0\n        for s in range(self.N):\n            for j in range(self.I):\n                out[idx] = codewords[j][s]\n                idx += 1\n        return out\n\n    def _emit_tap(self, n_out):\n        \"\"\"\n        Float32 marker vector (same length as byte output):\n          - 1.0 at frame start (index 0)\n          - 0.5 at each 255-symbol boundary (indices 255-1, 2*255-1, ...)\n          - 0.0 elsewhere\n        \"\"\"\n        tap = np.zeros(n_out, dtype=np.float32)\n        tap[0] = 1.0\n        for k in range(255, n_out + 1, 255):\n            if k - 1 < n_out:\n                tap[k - 1] = 0.5\n        return tap\n\n    # ----------------- Work -----------------\n    def general_work(self, input_items, output_items):\n        inp   = input_items[0]\n        out_b = output_items[0]  # bytes\n        out_f = output_items[1]  # floats\n\n        n_in    = len(inp)\n        n_out_b = len(out_b)\n        n_out_f = len(out_f)\n\n        if n_in == 0 or n_out_b == 0 or n_out_f == 0:\n            return 0\n\n        n_read = self.nitems_read(0)\n        tags   = self.get_tags_in_window(0, 0, n_in)\n\n        # find the first len_tag at/within the current window head\n        frame_tag = None\n        for t in tags:\n            if t.key == self.len_key:\n                rel = int(t.offset - n_read)\n                if rel <= 0:\n                    frame_tag = (t, rel)\n                    break\n        if frame_tag is None:\n            return 0\n\n        t, rel = frame_tag\n        if rel < 0:\n            to_consume = min(-rel, n_in)\n            self.consume(0, to_consume)\n            return 0\n\n        # need full frame in window\n        if n_in < self.tm_len:\n            return 0\n\n        out_len = self.N * self.I  # 255*I\n        if n_out_b < out_len or n_out_f < out_len:\n            return 0\n\n        # slice exactly one TM frame\n        tm = np.array(inp[:self.tm_len], dtype=np.uint8)\n\n        # de-mux → RS encode per branch → collect codewords\n        branches  = self._demux_round_robin(tm)\n        codewords = []\n        for j in range(self.I):\n            parity = self._rs_encode_223_255(branches[j])\n            cw     = np.concatenate([branches[j], np.frombuffer(parity, dtype=np.uint8)])  # 223+32\n            codewords.append(cw)\n\n        # interleave symbols → out0\n        inter = self._interleave_symbols(codewords)\n        out_b[:out_len] = inter\n\n        # float tap → out1\n        out_f[:out_len] = self._emit_tap(out_len)\n\n        # emit new len tag on output 0 (bytes)\n        self.add_item_tag(0, self.nitems_written(0), self.len_key, pmt.from_long(out_len))\n\n        # forward non-length tags to output 0 at frame head (optional)\n        if self._forward_all_tags:\n            for tg in tags:\n                if tg.key == self.len_key:\n                    continue\n                self.add_item_tag(0, self.nitems_written(0), tg.key, tg.value)\n\n        # consume one input frame\n        self.consume(0, self.tm_len)\n        # produce out_len items on BOTH outputs (same rate)\n        return out_len\n\n"
    alias: rs_I
    len_tag_key: '"packet_len"'
    tm_len: BYTES_PER_TM_FRAME
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_tm
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_rand
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\"\"\"\nlen_meter_ts_f32 — emits one float sample per frame equal to the length tag.\n\nInput : FLOATS (np.float32), tagged stream with 'packet_len' per frame.\nOutput: FLOATS (np.float32), 1 sample per frame = float(packet_len).\n\nTypical use:\n[float-tap] → len_meter_ts_f32 → QT GUI Number Sink\n\"\"\"\n\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, len_tag_key=\"packet_len\"):\n        gr.basic_block.__init__(self,\n            name=\"len_meter_ts_f32\",\n            in_sig=[np.float32],\n            out_sig=[np.float32],\n        )\n        self.len_key_str = str(len_tag_key)\n        self.len_key     = pmt.intern(self.len_key_str)\n\n        # We produce our own outputs; don't auto-forward tags.\n        try:\n            self.set_tag_propagation_policy(gr.block.TPP_DONT)\n        except Exception:\n            pass\n\n    def _first_len_tag_here(self, n_in):\n        \"\"\"Return first length tag at/after current read index within window.\"\"\"\n        tags = self.get_tags_in_window(0, 0, n_in)\n        if not tags:\n            return None\n        tags.sort(key=lambda t: int(t.offset))\n        for t in tags:\n            if pmt.equal(t.key, self.len_key):\n                return t\n        return None\n\n    def general_work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_in  = len(inp)\n        n_out = len(out)\n        if n_in == 0 or n_out == 0:\n            return 0\n\n        # Find the first length tag at/after the current read pointer\n        t = self._first_len_tag_here(n_in)\n        if t is None:\n            return 0\n\n        nread = self.nitems_read(0)\n        rel   = int(t.offset - nread)\n\n        # If the tag starts later in this window, advance to it\n        if rel > 0:\n            self.consume(0, rel)\n            return 0\n\n        # Tag is at current cursor; parse length\n        try:\n            L = int(pmt.to_long(t.value))\n        except Exception:\n            # If the tag value isn't a PMT integer, try to coerce\n            try:\n                L = int(str(t.value))\n            except Exception:\n                # Can't parse; drop one item to avoid deadlock\n                self.consume(0, 1)\n                return 0\n\n        # Wait until the full frame is present\n        if n_in < L:\n            return 0\n\n        # Emit one float with the length and consume exactly one frame\n        out[0] = float(L)\n        self.consume(0, L)\n        return 1\n\n"
    alias: len_rs
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_conv
    len_tag_key: '"packet_len"'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '4096'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '4096'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    alias: ns_tm
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2000'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    alias: ns_rand
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2000'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    alias: ns_rs
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    alias: ns_asm
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_1_1
  id: qtgui_number_sink
  parameters:
    alias: ns_conv
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}

connections:
- [blocks_tagged_stream_align_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', epy_block_5, '0']
- [epy_block_1, '0', blocks_file_sink_0_0_0_0, '0']
- [epy_block_1, '0', epy_block_4, '0']
- [epy_block_1, '0', epy_block_5_0, '0']
- [epy_block_2, '0', blocks_file_sink_0_1, '0']
- [epy_block_2, '0', epy_block_3, '0']
- [epy_block_2, '1', qtgui_number_sink_0_1_0, '0']
- [epy_block_3, '0', blocks_file_sink_0_0_0_2, '0']
- [epy_block_3, '0', blocks_tagged_stream_align_1, '0']
- [epy_block_3, '0', epy_block_5_3, '0']
- [epy_block_4, '0', blocks_file_sink_0_0_0, '0']
- [epy_block_4, '0', epy_block_2, '0']
- [epy_block_4, '1', epy_block_5_1, '0']
- [epy_block_5, '0', qtgui_number_sink_0, '0']
- [epy_block_5_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_5_1, '0', qtgui_number_sink_0_1, '0']
- [epy_block_5_3, '0', qtgui_number_sink_0_1_1, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_1, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
