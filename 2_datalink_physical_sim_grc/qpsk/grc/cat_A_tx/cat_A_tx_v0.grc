options:
  parameters:
    author: Joshua Wille
    generate_options: qt_gui
    id: cat_A_tx_v0
    output_language: python
    title: cat_A_tx_v0
  states: {}

blocks:
- name: BITS_PER_FRAME
  id: variable
  parameters:
    value: BYTES_PER_FRAME*8
  states: {}
- name: BYTES_PER_FRAME
  id: variable
  parameters:
    value: '1115'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: beta
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: delay_Q
  id: variable
  parameters:
    value: sps/2
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_bw
  id: variable
  parameters:
    value: Rs*(1+beta)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,    Rs*sps,     Rs,    alpha,   span*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/tx_out.cfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/cadu_v0.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    alias: keep_even
    m: '1'
    n: '2'
    offset: '1'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    alias: keep_old
    m: '1'
    n: '2'
    offset: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: BYTES_PER_FRAME
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_3
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(BYTES_PER_FRAME/2) * sps
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    alias: sym_Q
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    alias: sym_I
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: rrc_I
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_taps
    type: fff
  states: {}
- name: rrc_Q
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    samp_delay: int(delay_Q)
    taps: rrc_taps
    type: fff
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_m_in_n_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_keep_m_in_n_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_tagged_stream_3, '0']
- [blocks_repack_bits_bb_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_keep_m_in_n_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_3, '0', blocks_tagged_stream_align_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', rrc_I, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', rrc_Q, '0']
- [rrc_I, '0', blocks_float_to_complex_0, '1']
- [rrc_Q, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
