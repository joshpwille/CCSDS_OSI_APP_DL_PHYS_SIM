options:
  parameters:
    generate_options: qt_gui
    id: sync_coding_v0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ASM_BYTES
  id: variable
  parameters:
    comment: ASM = 0x1A CF FC 1D (4 bytes)
    value: len(ASM_MARKER)
  states: {}
- name: ASM_MARKER
  id: variable
  parameters:
    value: (0x1A, 0xCF, 0xFC, 0x1D)
  states: {}
- name: BYTES_PER_TM_FRAME
  id: variable
  parameters:
    value: 223 * I_RS
  states: {}
- name: CADU_RS_ASM_BYTES
  id: variable
  parameters:
    value: RS_BYTES + ASM_BYTES
  states: {}
- name: DATA_RATE_BPS
  id: variable
  parameters:
    value: (Rs*k*(1/r))
  states: {}
- name: FILE_BYTES
  id: variable
  parameters:
    value: __import__('os').path.getsize(FILE_PATH)
  states: {}
- name: FILE_PATH
  id: variable
  parameters:
    value: '"/home/dogg/Downloads/tm_stagin_grc/qpsk/data/SPPencaps_CFDP_metadata_tx.bin"'
  states: {}
- name: HEAD_SPACING
  id: variable
  parameters:
    value: BYTES_PER_TM_FRAME * N_FRAMES
  states: {}
- name: I_RS
  id: variable
  parameters:
    comment: RS interleave depth (because 223 × 5 = 1115)
    value: '5'
  states: {}
- name: K
  id: variable
  parameters:
    value: '7'
  states: {}
- name: N_FRAMES
  id: variable
  parameters:
    value: (FILE_BYTES + SPP_LEN - 1) // SPP_LEN
  states: {}
- name: POST_CONV_BITS
  id: variable
  parameters:
    value: CADU_RS_ASM_BYTES *8*(1/r)
  states: {}
- name: POST_CONV_BYTES
  id: variable
  parameters:
    value: POST_CONV_BITS/8
  states: {}
- name: RAND_SEED_ALL_ONES
  id: variable
  parameters:
    value: '0x7FFF'
  states: {}
- name: RS_BYTES
  id: variable
  parameters:
    value: 255 * I_RS
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: SPP_LEN
  id: variable
  parameters:
    value: FILE_BYTES
  states: {}
- name: TM_BODY_LEN
  id: variable
  parameters:
    value: BYTES_PER_TM_FRAME - TM_HDR_LEN
  states: {}
- name: TM_HDR_LEN
  id: variable
  parameters:
    value: '6'
  states: {}
- name: k
  id: variable
  parameters:
    value: '2'
  states: {}
- name: r
  id: variable
  parameters:
    value: 1/2
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/cadu_v0.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    alias: tm_out
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/tm_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    alias: rs_out
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/rs_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    alias: rand_out
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/rand_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_2
  id: blocks_file_sink
  parameters:
    alias: conv_out
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/conv_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    alias: tag_out
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/tag_out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    alias: asm_out
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/art/asm_out.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/SPPencaps_CFDP_metadata_tx.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    alias: throttle_datalink
    samples_per_second: DATA_RATE_BPS
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "# tm_framer_ccsds_epy.py\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    \"\"\"\n    CCSDS TM Transfer Frame framer (packetized mode, SyncFlag=0).\n    In : uchar stream, tagged per Space Packet (len_tag_key = SPP length in BYTES)\n    Out: uchar stream, fixed-length TM frames (len_tag_key = frame_len)\n\n    • 6B Primary Header: TFVN/SCID/VCID/OCF + MC/VC counters + Data Field Status\n    • Data Field Status (packetized): SyncFlag=0, FHP computed per frame\n      - FHP = 0..TFDF_len-1 if a packet header starts in this TFDF\n      - FHP = 0x7FF if the frame contains only packet continuation bytes\n      - (Optional) 0x7FE if Only-Idle-Data (if emit_idle_when_empty=True and no SPPs)\n    • Packs multiple SPPs if they fit; segments across frames when needed\n    • Optional FECF (CRC-16-IBM) appended after TFDF when include_fecf=True\n    • Maintains Master/Virtual Channel frame counters (mod-256)\n\n    Parameters\n      scid: 0..1023 (10b)\n      vcid: 0..7    (3b)\n      ocf_present: bool (sets OCF flag in header only; no OCF bytes are added)\n      frame_len: total TM frame length in bytes (header + TFDF [+ FECF])\n      len_tag_key: tag name for lengths (default \"packet_len\")\n      include_fecf: append CRC-16 FECF (True/False)\n      idle_fill: byte used for idle padding if emit_idle_when_empty=True\n      emit_idle_when_empty: when True and no SPP available, send OID frames (FHP=0x7FE)\n    \"\"\"\n    def __init__(self,\n                 scid=0, vcid=0, ocf_present=False,\n                 frame_len=1115,\n                 len_tag_key=\"packet_len\",\n                 include_fecf=False,\n                 idle_fill=0x55,\n                 emit_idle_when_empty=False):\n        gr.basic_block.__init__(self,\n            name=\"tm_framer_ccsds\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8],\n        )\n        # ---- config ----\n        self.scid  = int(scid) & 0x3FF\n        self.vcid  = int(vcid) & 0x7\n        self.ocf_present = bool(ocf_present)\n        self.len_key_str = str(len_tag_key)\n        self.len_key = pmt.intern(self.len_key_str)\n        self.include_fecf = bool(include_fecf)\n        self.emit_idle = bool(emit_idle_when_empty)\n        self.idle_fill = int(idle_fill) & 0xFF\n\n        # lengths\n        self.header_len = 6\n        self.fecf_len   = 2 if self.include_fecf else 0\n        self.frame_len  = int(frame_len)\n        assert self.frame_len >= self.header_len + self.fecf_len + 1, \"frame_len too small\"\n        self.tfdf_len   = self.frame_len - self.header_len - self.fecf_len\n\n        # counters\n        self.mc_cnt = 0\n        self.vc_cnt = 0\n\n        # input buffering / queues\n        self._inbuf = bytearray()\n        self._pending_tags = []  # (rel_offset, spp_len)\n        self._spp_queue = []     # dicts: { 'data': bytearray, 'pos': 0, 'len': L }\n        self._cur_pkt = None     # currently-being-segmented packet\n\n        # we re-emit only our own frame length tags\n        self.set_tag_propagation_policy(gr.TPP_DONT)\n\n    # --------------- CRC-16-IBM (FECF) ----------------\n    @staticmethod\n    def _crc16_ibm(data, init=0xFFFF):\n        crc = init\n        for b in data:\n            crc ^= (b << 8) & 0xFFFF\n            for _ in range(8):\n                if crc & 0x8000:\n                    crc = ((crc << 1) ^ 0x1021) & 0xFFFF\n                else:\n                    crc = (crc << 1) & 0xFFFF\n        return crc & 0xFFFF\n\n    # --------------- Primary Header packer ---------------\n    def _pack_primary_header(self, fhp, sync_flag=0, sec_hdr_flag=0,\n                             pkt_order_flag=0, seg_len_id=0):\n        \"\"\"\n        16 bits: TFVN(2)=0, SCID(10), VCID(3), OCF(1)\n        8  bits: MC frame count\n        8  bits: VC frame count\n        16 bits: Data Field Status: [SecHdr(1) Sync(1) PktOrd(1) SegLen(2) FHP(11)]\n        \"\"\"\n        tfvn = 0\n        word0 = ((tfvn & 0x3) << 14) | ((self.scid & 0x3FF) << 4) | ((self.vcid & 0x7) << 1) | (1 if self.ocf_present else 0)\n        b0 = (word0 >> 8) & 0xFF\n        b1 = (word0 >> 0) & 0xFF\n\n        dfs = ((sec_hdr_flag & 1) << 15) \\\n            | ((sync_flag   & 1) << 14) \\\n            | ((pkt_order_flag & 1) << 13) \\\n            | ((seg_len_id & 0x3) << 11) \\\n            | (fhp & 0x7FF)\n        b4 = (dfs >> 8) & 0xFF\n        b5 = (dfs >> 0) & 0xFF\n\n        hdr = bytearray(6)\n        hdr[0] = b0; hdr[1] = b1\n        hdr[2] = self.mc_cnt & 0xFF\n        hdr[3] = self.vc_cnt & 0xFF\n        hdr[4] = b4; hdr[5] = b5\n        return bytes(hdr)\n\n    def _advance_counters(self):\n        self.mc_cnt = (self.mc_cnt + 1) & 0xFF\n        self.vc_cnt = (self.vc_cnt + 1) & 0xFF\n\n    # --------------- Input tag handling ---------------\n    def _collect_spp_tags(self, n_input):\n        in0 = 0\n        nread = self.nitems_read(in0)\n        tags = self.get_tags_in_range(in0, nread, nread + n_input, self.len_key)\n        if not tags:\n            return\n        tags = sorted(tags, key=lambda t: int(t.offset))\n        for t in tags:\n            if not pmt.is_integer(t.value): continue\n            L = int(pmt.to_long(t.value))\n            if L <= 0: continue\n            rel = int(t.offset - nread)\n            self._pending_tags.append((rel, L))\n\n    # --------------- Work ---------------\n    def general_work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n        n_in, n_out = len(inp), len(out)\n        if n_out < self.frame_len:\n            return 0\n\n        produced = 0\n\n        # Ingest bytes and discover new SPP starts in this call\n        if n_in:\n            self._inbuf += bytes(inp)\n            self._collect_spp_tags(n_in)\n\n        # Carve complete SPPs out of _inbuf into _spp_queue\n        while self._pending_tags:\n            rel_off, L = self._pending_tags[0]\n            if rel_off < 0:\n                # tag before buffer head; drop it (shouldn't happen with sane upstream)\n                self._pending_tags.pop(0)\n                continue\n            if len(self._inbuf) < rel_off + L:\n                break  # wait for more bytes\n            pkt = bytes(self._inbuf[rel_off:rel_off+L])\n            # remove everything up to end-of-packet to keep indices simple\n            del self._inbuf[:rel_off+L]\n            # adjust remaining tags\n            self._pending_tags = [(off - (rel_off+L), l) for (off, l) in self._pending_tags[1:]]\n            # queue SPP\n            self._spp_queue.append({'data': bytearray(pkt), 'pos': 0, 'len': L})\n\n        # Assemble as many full frames as we have space for\n        while n_out - produced >= self.frame_len:\n            tfdf = bytearray(self.tfdf_len)\n            cursor = 0\n            header_starts = []  # offsets of SPP header starts within this TFDF\n\n            # 1) If continuing a split packet, place its continuation first\n            if self._cur_pkt is not None:\n                pkt = self._cur_pkt\n                rem = pkt['len'] - pkt['pos']\n                take = min(rem, self.tfdf_len - cursor)\n                if take > 0:\n                    tfdf[cursor:cursor+take] = pkt['data'][pkt['pos']:pkt['pos']+take]\n                    pkt['pos'] += take\n                    cursor += take\n                if pkt['pos'] >= pkt['len']:\n                    self._cur_pkt = None  # finished this packet\n\n            # 2) Place as many *new* SPPs as fit; record each header start\n            while cursor < self.tfdf_len and self._spp_queue:\n                pkt = self._spp_queue[0]\n                header_starts.append(cursor)  # a new packet header starts here\n                L = pkt['len']\n                room = self.tfdf_len - cursor\n                if L <= room:\n                    tfdf[cursor:cursor+L] = pkt['data']\n                    cursor += L\n                    self._spp_queue.pop(0)\n                else:\n                    # split across frames\n                    take = room\n                    if take > 0:\n                        tfdf[cursor:cursor+take] = pkt['data'][:take]\n                        pkt['pos'] = take\n                        self._cur_pkt = pkt\n                        self._spp_queue.pop(0)\n                    cursor = self.tfdf_len\n                    break\n\n            # 3) If there is still space and no data, optionally emit Only-Idle-Data\n            only_idle = False\n            if cursor < self.tfdf_len:\n                if self.emit_idle and not header_starts and self._cur_pkt is None and not self._spp_queue:\n                    tfdf[cursor:self.tfdf_len] = bytes([self.idle_fill]) * (self.tfdf_len - cursor)\n                    only_idle = True\n                else:\n                    # leave zeros (lab mode); production systems should prefer idle\n                    pass\n\n            # 4) Compute FHP\n            if only_idle:\n                fhp = 0x7FE\n            else:\n                fhp = header_starts[0] if header_starts else 0x7FF\n\n            # 5) Build frame (header + TFDF [+ FECF])\n            hdr = self._pack_primary_header(fhp=fhp, sync_flag=0, sec_hdr_flag=0, pkt_order_flag=0, seg_len_id=0)\n            frame_wo_fecf = hdr + bytes(tfdf)\n            if self.include_fecf:\n                crc = self._crc16_ibm(frame_wo_fecf)\n                fecf = bytes([(crc >> 8) & 0xFF, crc & 0xFF])\n                frame = frame_wo_fecf + fecf\n            else:\n                frame = frame_wo_fecf\n\n            # 6) Output and tag\n            out[produced:produced+len(frame)] = np.frombuffer(frame, dtype=np.uint8)\n            self.add_item_tag(0, self.nitems_written(0) + produced, self.len_key, pmt.from_long(len(frame)))\n\n            # 7) advance counters and produced\n            self._advance_counters()\n            produced += len(frame)\n\n            # If we didn't actually place any data and also didn't permit idle,\n            # break to avoid emitting empty frames.\n            if cursor == 0 and not self.emit_idle:\n                break\n\n        # Consume all input provided this call (we manage our own buffers)\n        self.consume(0, n_in)\n        return produced\n\n"
    alias: tm_framer
    emit_idle_when_empty: ''
    frame_len: ''
    idle_fill: ''
    include_fecf: ''
    len_tag_key: '"packet_len"'
    ocf_present: ''
    scid: ''
    vcid: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.basic_block):\n    \"\"\"\n    CCSDS TM byte-wise randomizer / de-randomizer.\n\n    - LFSR: x^15 + x^14 + 1 (15-bit), default seed 0x7FFF (all ones)\n    - Restarts PN at each frame, where frame boundaries are marked by a\n      length tag (e.g., \"packet_len\") giving the frame length in BYTES.\n    - Symmetric XOR ⇒ works for randomize *and* derandomize.\n\n    Params:\n      len_tag_key=\"packet_len\", seed=0x7FFF, restart_per_frame=True, enabled=True\n    \"\"\"\n\n    def __init__(self, len_tag_key=\"packet_len\", seed=0x7FFF,\n                 restart_per_frame=True, enabled=True):\n        gr.basic_block.__init__(self,\n            name=\"ccsds_tm_randomizer\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8])\n\n        # --- Params\n        self.len_tag_key_str = str(len_tag_key)\n        self.len_tag_key = pmt.intern(self.len_tag_key_str)\n        self.seed = int(seed) & 0x7FFF\n        self.restart_per_frame = bool(restart_per_frame)\n        self.enabled = bool(enabled)\n\n        # --- State\n        self._lfsr = self.seed\n        self._frame_bytes_left = 0\n\n        # IMPORTANT: don't auto-propagate tags; we will forward/re-emit explicitly\n        self.set_tag_propagation_policy(gr.TPP_DONT)\n\n    # ---- PN generator (CCSDS 15-bit LFSR) ----\n    @staticmethod\n    def _step_lfsr(state):\n        # taps at bit14 and bit13 (0-based, 15-bit register [14..0])\n        new_bit = ((state >> 14) ^ (state >> 13)) & 0x1\n        state = ((state << 1) & 0x7FFF) | new_bit\n        return state\n\n    def _next_pn_byte(self):\n        out_byte = 0\n        for _ in range(8):\n            pn_bit = (self._lfsr >> 14) & 0x1   # MSB before stepping\n            out_byte = ((out_byte << 1) | pn_bit) & 0xFF\n            self._lfsr = self._step_lfsr(self._lfsr)\n        return out_byte\n\n    def _reset_pn(self):\n        self._lfsr = self.seed\n\n    # ---- Tag forwarding helper ----\n    def _forward_tags(self, n_input, produced):\n        \"\"\"Forward all input tags EXCEPT the length tag (we re-emit it).\"\"\"\n        in0 = 0\n        nread  = self.nitems_read(in0)\n        out_hd = self.nitems_written(in0) + produced\n\n        for t in self.get_tags_in_range(in0, nread, nread + n_input):\n            if pmt.equal(t.key, self.len_tag_key):\n                continue  # we'll re-emit a clean length tag at frame start\n            rel = t.offset - nread\n            self.add_item_tag(0, out_hd + rel, t.key, t.value)\n\n    # ---- Detect incoming length tags within current window ----\n    def _consume_length_tags(self, n_input):\n        \"\"\"Return sorted list of (rel_offset, frame_len) for new frames in-window.\"\"\"\n        in0 = 0\n        nread = self.nitems_read(in0)\n        found = []\n\n        # Ask GNU Radio to filter by key on our behalf\n        for t in self.get_tags_in_range(in0, nread, nread + n_input, self.len_tag_key):\n            try:\n                L = int(pmt.to_long(t.value))\n            except Exception:\n                continue\n            if L > 0:\n                rel = t.offset - nread\n                found.append((rel, L))\n\n        found.sort(key=lambda x: x[0])\n        return found\n\n    def general_work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_in  = len(inp)\n        n_out = len(out)\n        if n_in == 0 or n_out == 0:\n            return 0\n\n        produced = 0\n        consumed = 0\n\n        # Forward non-length tags with corrected offsets\n        self._forward_tags(n_in, produced=0)\n\n        # Collect any new frame-start tags appearing in this call\n        starts = self._consume_length_tags(n_in)\n        cursor = 0  # bytes already handled from 'inp' in this call\n\n        def process_chunk(chunk_len):\n            nonlocal produced, consumed, cursor\n            if chunk_len <= 0:\n                return\n            n = min(chunk_len, n_out - produced)\n            if n <= 0:\n                return\n\n            if not self.enabled or self._frame_bytes_left <= 0:\n                out[produced:produced+n] = inp[cursor:cursor+n]\n            else:\n                to_rand = min(n, self._frame_bytes_left)\n                for i in range(to_rand):\n                    out[produced+i] = inp[cursor+i] ^ self._next_pn_byte()\n                if n > to_rand:\n                    out[produced+to_rand:produced+n] = inp[cursor+to_rand:cursor+n]\n                self._frame_bytes_left -= to_rand\n\n            produced += n\n            consumed += n\n            cursor   += n\n\n        # Walk input; when we hit a new frame start, (re)seed and re-tag\n        for rel_off, frame_len in starts:\n            # bytes before the frame start (pass-through or continuing prior frame)\n            pre = rel_off - cursor\n            if pre > 0:\n                process_chunk(pre)\n                if produced >= n_out:\n                    break\n\n            # Start a new frame exactly here\n            if self.restart_per_frame:\n                self._reset_pn()\n            self._frame_bytes_left = frame_len\n\n            # Re-emit a clean length tag at the output head for this frame\n            self.add_item_tag(0,\n                              self.nitems_written(0) + produced,\n                              self.len_tag_key,\n                              pmt.from_long(frame_len))\n\n            # processing continues; next process_chunk() will apply PN\n\n        # After handling all starts, process the remainder of input window\n        if produced < n_out and cursor < n_in:\n            process_chunk(n_in - cursor)\n\n        self.consume(0, consumed)\n        return produced\n\n"
    alias: tm_rand
    enabled: 'True'
    len_tag_key: '"packet_len"'
    restart_per_frame: 'True'
    seed: RAND_SEED_ALL_ONES
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      ASM inserter for CCSDS CADU.

      Input : bytes (uchar), tagged stream with one length tag per frame (len_tag_key)
      Output: bytes (uchar), same frame with ASM prepended; packet_len increased by len(ASM)
      """

      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len", asm_word=(0x1A, 0xCF, 0xFC, 0x1D)):
              gr.basic_block.__init__(self,
                  name="asm_inserter",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8],
              )
              self.len_key  = pmt.intern(str(len_tag_key))
              # use your canvas variable; GRC will pass ASM_MARKER here
              self.asm      = bytes(asm_word) if asm_word is not None else b""
              self.asm_len  = len(self.asm)

              # We do not create headers or bodies here; we just insert ASM.

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)
              if n_in == 0:
                  return 0

              n_read = self.nitems_read(0)

              # Look for the first length tag in the current window
              tags = self.get_tags_in_window(0, 0, n_in, self.len_key)
              if not tags:
                  return 0

              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  # Align to the tag (start of frame)
                  self.consume(0, rel)
                  return 0

              # Length of the incoming frame payload (pre-ASM)
              L_in = int(pmt.to_long(t.value))
              if n_in < L_in:
                  # wait for the whole frame to arrive
                  return 0

              L_out = L_in + self.asm_len  # <— THIS is the “+4” (or +len(ASM_MARKER))

              if len(out) < L_out:
                  # need more output buffer
                  return 0

              # write ASM then the original frame bytes
              if self.asm_len:
                  out[:self.asm_len] = np.frombuffer(self.asm, dtype=np.uint8)
              out[self.asm_len:self.asm_len+L_in] = inp[:L_in]

              # Re-tag output with the new length
              self.add_item_tag(0, self.nitems_written(0), self.len_key, pmt.from_long(L_out))

              # Consume exactly the input frame
              self.consume(0, L_in)
              return L_out
    alias: asm_ins
    asm_word: ASM_MARKER
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    K: K
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          CCSDS convolutional encoder (K=7, r=1/2, generators 171/133 octal).
          Input : BYTES with per-frame 'packet_len' tag (pre-FEC CADU: TM+ASM)
          Output: BYTES with updated 'packet_len' tag (post-FEC CADU bytes)
          Emits the output length tag exactly at the first encoded byte of each frame.
          """
          def __init__(self,
                       len_tag_key="packet_len",
                       K=7,
                       gen0=0o171,
                       gen1=0o133,
                       msb_first=True,
                       reset_each_frame=True):
              gr.sync_block.__init__(
                  self,
                  name="ccsds_conv_k7_r12_epy",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8],
              )
              # Params
              self.len_tag_key = str(len_tag_key)
              self.len_key_sym = pmt.intern(self.len_tag_key)
              self.K = int(K)
              self.gen0 = np.uint32(gen0)
              self.gen1 = np.uint32(gen1)
              self._mask = np.uint32((1 << self.K) - 1)
              self.msb_first = bool(msb_first)
              self.reset_each_frame = bool(reset_each_frame)

              # Internal
              self._inbuf = bytearray()
              self._outbuf = bytearray()
              self._frame_queue = []     # pending input frame lengths (bytes)
              self._state = np.uint32(0)

              # Tag scheduling for output
              self._pending_out_frames = []  # list of encoded frame lengths (bytes)
              self._head_remaining = 0       # bytes remaining to write in current head frame

              # We will re-emit only our packet_len; do not propagate all tags blindly
              self.set_tag_propagation_policy(gr.TPP_DONT)

          # ---------- helpers ----------
          @staticmethod
          def _parity_u32(x):
              cnt = 0
              while x:
                  x &= (x - 1)
                  cnt ^= 1
              return cnt & 1

          def _bytes_to_bits(self, b):
              arr = np.frombuffer(bytes(b), dtype=np.uint8)
              if self.msb_first:
                  shifts = np.arange(7, -1, -1, dtype=np.uint8)
              else:
                  shifts = np.arange(0, 8, 1, dtype=np.uint8)
              bits = ((arr[:, None] >> shifts[None, :]) & 1).astype(np.uint8)
              return bits.reshape(-1)

          def _bits_to_bytes(self, bits):
              n = bits.size
              pad = (8 - (n % 8)) % 8
              if pad:
                  bits = np.concatenate([bits, np.zeros(pad, dtype=np.uint8)])
              bits = bits.reshape(-1, 8)
              if self.msb_first:
                  shifts = np.arange(7, -1, -1, dtype=np.uint8)
              else:
                  shifts = np.arange(0, 8, 1, dtype=np.uint8)
              packed = (bits * (1 << shifts)).sum(axis=1).astype(np.uint8)
              return bytes(packed)

          def _conv_encode_bits(self, in_bits):
              out = np.empty(in_bits.size * 2, dtype=np.uint8)
              state = self._state
              mask = self._mask
              g0 = self.gen0
              g1 = self.gen1
              idx = 0
              for b in in_bits:
                  state = ((state << np.uint32(1)) | np.uint32(int(b & 1))) & mask
                  out[idx]   = self._parity_u32(int(state & g0))
                  out[idx+1] = self._parity_u32(int(state & g1))
                  idx += 2
              if self.reset_each_frame:
                  self._state = np.uint32(0)
              else:
                  self._state = state
              return out

          # ---------- input frame parsing ----------
          def _enqueue_len_tags(self, ninput_items):
              tags = self.get_tags_in_window(0, 0, ninput_items)
              for t in tags:
                  try:
                      key_str = pmt.symbol_to_string(t.key)
                  except Exception:
                      continue
                  if key_str == self.len_tag_key and pmt.is_integer(t.value):
                      L = int(pmt.to_long(t.value))
                      if L > 0:
                          self._frame_queue.append(L)

          def _process_frames_to_outbuf(self):
              # Convert as many full frames as are available in _inbuf
              while self._frame_queue:
                  need = self._frame_queue[0]
                  if len(self._inbuf) < need:
                      break
                  # consume one input frame
                  frame = self._inbuf[:need]
                  del self._inbuf[:need]
                  self._frame_queue.pop(0)

                  # bytes -> bits -> encode -> bytes
                  bits_in  = self._bytes_to_bits(frame)
                  bits_out = self._conv_encode_bits(bits_in)
                  enc      = self._bits_to_bytes(bits_out)  # exactly 2*need bytes

                  # append to output buffer
                  start_new_frame = (self._head_remaining == 0 and len(self._pending_out_frames) == 0 and len(self._outbuf) == 0)
                  self._outbuf += enc

                  # queue this encoded frame length for tag scheduling
                  self._pending_out_frames.append(len(enc))
                  # Note: we don't emit the tag yet; we emit it when the first byte of this frame is written.

          # ---------- work ----------
          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              n_in = len(in0)
              if n_in:
                  # ingest bytes and discover new frame tags
                  self._inbuf += bytes(in0)
                  self._enqueue_len_tags(n_in)
                  self._process_frames_to_outbuf()

              # nothing to output?
              if not self._outbuf:
                  self.consume_each(n_in)
                  return 0

              ow = self.nitems_written(0)
              space = len(out0)
              produced = 0

              # Before writing any bytes in this call, if we are at a frame boundary,
              # emit the length tag at the current write head.
              while space > 0 and self._outbuf:
                  if self._head_remaining == 0:
                      # Starting a new encoded frame on the output stream
                      if not self._pending_out_frames:
                          # Shouldn't happen, but guard anyway
                          break
                      self._head_remaining = self._pending_out_frames[0]
                      # Emit the tag RIGHT HERE at the start boundary
                      self.add_item_tag(0, ow + produced, self.len_key_sym, pmt.from_long(self._head_remaining))

                  # write up to the remainder of this frame (or available space)
                  chunk = min(space, self._head_remaining, len(self._outbuf))
                  if chunk <= 0:
                      break

                  out0[produced:produced+chunk] = np.frombuffer(self._outbuf[:chunk], dtype=np.uint8)
                  del self._outbuf[:chunk]

                  produced += chunk
                  space    -= chunk
                  self._head_remaining -= chunk

                  if self._head_remaining == 0:
                      # finished a frame; pop it
                      if self._pending_out_frames:
                          self._pending_out_frames.pop(0)
                      # loop continues; if there's still space and more frames queued,
                      # the next iteration will emit the next tag at the new boundary.

              self.consume_each(n_in)
              return produced
    alias: conv_k7r12
    gen0: 0o171
    gen1: 0o133
    len_tag_key: '"packet_len"'
    msb_first: 'True'
    reset_each_frame: 'True'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    I: I_RS
    _source_code: |
      """
      CCSDS RS(255,223) encoder with symbol interleaving depth I (round-robin),
      for TM frames already randomized. One input TM frame of length tm_len=223*I
      becomes an interleaved RS codeblock of length 255*I.

      Input : bytes (uchar), tagged stream with len_tag_key = 223*I
      Output: bytes (uchar), tagged stream with len_tag_key = 255*I
      """

      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len", I=5, tm_len=1115):
              gr.basic_block.__init__(self,
                  name="rs255_223_interleave_I",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8],
              )
              self.len_key = pmt.intern(str(len_tag_key))
              self.I = int(I)
              self.tm_len = int(tm_len)

              # --- RS(255,223) constants ---
              self.N = 255
              self.K = 223
              self.NPAR = self.N - self.K  # 32 parity bytes

              # Sanity check: input length must be 223*I
              if self.tm_len != self.K * self.I:
                  raise ValueError(f"tm_len ({self.tm_len}) must equal 223*I ({self.K*self.I})")

              # Build GF(256) tables with primitive polynomial 0x11D
              self._gf_init(prim=0x11D)

              # Build generator polynomial g(x) = Π_{i=1..NPAR} (x - α^i)
              # (Common RS(255,223) choice; for strict CCSDS compliance this matches practice for TM.)
              self.gen = self._rs_generator(self.NPAR)

          # ---------------- GF(256) helpers ----------------
          def _gf_init(self, prim=0x11D):
              self.gf_exp = np.zeros(512, dtype=np.uint8)
              self.gf_log = np.zeros(256, dtype=np.int16) - 1
              x = 1
              for i in range(255):
                  self.gf_exp[i] = x
                  self.gf_log[x] = i
                  x <<= 1
                  if x & 0x100:
                      x ^= prim
              # duplicate for fast wrap
              self.gf_exp[255:510] = self.gf_exp[:255]
              self.gf_exp[510:] = self.gf_exp[:2]


          def _gf_add(self, a, b):  # = subtract
              return a ^ b

          def _gf_mul(self, a, b):
              if a == 0 or b == 0:
                  return 0
              return int(self.gf_exp[int(self.gf_log[a]) + int(self.gf_log[b])])

          def _poly_scale(self, p, x):
              if x == 0:
                  return np.zeros_like(p)
              return np.array([self._gf_mul(int(c), x) for c in p], dtype=np.uint8)

          def _poly_add(self, p, q):
              # align lengths (MSB first)
              if len(p) < len(q):
                  p = np.pad(p, (len(q)-len(p), 0), constant_values=0)
              elif len(q) < len(p):
                  q = np.pad(q, (len(p)-len(q), 0), constant_values=0)
              return np.array([self._gf_add(int(a), int(b)) for a, b in zip(p, q)], dtype=np.uint8)

          def _rs_generator(self, nsym):
              g = np.array([1], dtype=np.uint8)
              for i in range(1, nsym+1):
                  # multiply by (x - α^i)
                  term = np.array([1, self.gf_exp[i]], dtype=np.uint8)
                  g = self._poly_mul(g, term)
              return g

          def _poly_mul(self, p, q):
              r = np.zeros(len(p)+len(q)-1, dtype=np.uint8)
              for i, a in enumerate(p):
                  if a == 0: continue
                  for j, b in enumerate(q):
                      if b == 0: continue
                      r[i+j] ^= self._gf_mul(int(a), int(b))
              return r

          def _rs_encode_223_255(self, data):
              """Return parity bytes for a 223-byte message."""
              if len(data) != self.K:
                  raise ValueError("RS encoder expects exactly 223 data bytes")
              # remainder of x^(NPAR) * data(x) divided by g(x)
              rem = np.zeros(self.NPAR, dtype=np.uint8)
              for d in data:
                  coef = d ^ rem[0]
                  # shift left by 1 (drop MSB), append 0
                  rem = np.concatenate([rem[1:], np.array([0], dtype=np.uint8)])
                  if coef != 0:
                      # rem = rem ^ (coef * g[1..])
                      for j in range(self.NPAR):
                          rem[j] ^= self._gf_mul(int(self.gen[j+1]), int(coef))
              return bytes(rem)  # parity

          # -------------- Work: one TM frame → I interleaved RS codewords --------------
          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_in = len(inp)
              if n_in == 0 or len(out) == 0:
                  return 0

              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n_in, self.len_key)
              if not tags:
                  return 0

              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel)
                  return 0

              L = int(pmt.to_long(t.value))
              if L < self.tm_len or n_in < self.tm_len:
                  # need the full TM frame
                  return 0

              # Take exactly one TM frame
              tm = np.array(inp[:self.tm_len], dtype=np.uint8)

              # Demultiplex into I branches (round-robin)
              # branch j gets bytes tm[j], tm[j+I], tm[j+2I], ... total 223 each
              branches = []
              for j in range(self.I):
                  branch = tm[j::self.I]
                  if len(branch) != self.K:
                      # Should not happen if tm_len == 223*I
                      branch = np.pad(branch, (0, self.K - len(branch)), constant_values=0)
                  branches.append(np.array(branch, dtype=np.uint8))

              # RS encode each branch and form full 255-byte codewords
              codewords = []
              for j in range(self.I):
                  parity = self._rs_encode_223_255(branches[j])
                  cw = bytes(branches[j].tolist()) + parity  # 223 + 32
                  codewords.append(np.frombuffer(cw, dtype=np.uint8))

              # Multiplex interleaver output: cw0[0], cw1[0], ..., cw{I-1}[0], cw0[1], ...
              out_len = self.N * self.I  # 255*I
              if len(out) < out_len:
                  return 0

              write_idx = 0
              for sym_idx in range(self.N):
                  for j in range(self.I):
                      out[write_idx] = codewords[j][sym_idx]
                      write_idx += 1

              # Emit new packet_len tag (255*I) at output head
              self.add_item_tag(0, self.nitems_written(0), self.len_key, pmt.from_long(out_len))

              # Consume exactly one TM frame worth of input
              self.consume(0, self.tm_len)
              return out_len
    alias: rs_I
    len_tag_key: '"packet_len"'
    tm_len: BYTES_PER_TM_FRAME
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_tm
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_rand
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_rs
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_asm
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_conv
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_5_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np, pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, len_tag_key="packet_len"):
              gr.basic_block.__init__(self, name="len_meter_ts",
                                      in_sig=[np.uint8], out_sig=[np.float32])
              self.len_key = pmt.intern(len_tag_key)

          def general_work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              if n == 0 or len(out) == 0:
                  return 0
              n_read = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, n, self.len_key)
              if not tags:
                  return 0
              t = tags[0]
              rel = int(t.offset - n_read)
              if rel > 0:
                  self.consume(0, rel); 
                  return 0
              L = int(pmt.to_long(t.value))
              if n < L:  # wait for full frame in this window
                  return 0
              out[0] = float(L)
              self.consume(0, L)   # advance exactly one frame
              return 1
    alias: len_tagger
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.basic_block):\n    \"\"\"\n    Reads CCSDS Space Packets from a raw byte stream and adds a 'packet_len' tag\n    at the start of each packet. Assumes packets are concatenated back-to-back.\n    CCSDS primary header: 6 bytes total; bytes [4:6] is Packet Length (big-endian)\n    meaning: total bytes in the Data Field minus 1. So total packet bytes =\n    6 + (PacketLength + 1).\n    \"\"\"\n    def __init__(self, len_tag_key=\"packet_len\"):\n        gr.basic_block.__init__(self,\n            name=\"spp_len_tagger\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint8])\n        self.len_tag_key = pmt.intern(len_tag_key)\n        self._buf = bytearray()\n        self._abs_out = 0  # absolute output item index\n\n    def general_work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        # append new input to buffer\n        self._buf += bytes(inp.tobytes())\n\n        produced = 0\n        consumed = len(inp)\n\n        # process complete packets from buffer\n        while True:\n            if len(self._buf) < 6:\n                break  # need full primary header\n\n            # CCSDS is big-endian\n            pkt_len_field = (self._buf[4] << 8) | self._buf[5]\n            total_len = 6 + (pkt_len_field + 1)  # primary hdr + data field\n\n            if len(self._buf) < total_len:\n                break  # wait for full packet\n\n            # emit a packet_len tag at the *current* output absolute index\n            self.add_item_tag(0, self._abs_out, self.len_tag_key, pmt.from_long(total_len))\n\n            # copy this packet to output\n            n = min(len(out) - produced, total_len)\n            if n < total_len:\n                # not enough output space this call\n                break\n\n            out[produced:produced+total_len] = np.frombuffer(self._buf[:total_len], dtype=np.uint8)\n            produced += total_len\n            self._abs_out += total_len\n\n            # drop packet from buffer\n            del self._buf[:total_len]\n\n        # if there's leftover room in out, copy whatever we can (no tags)\n        spill = min(len(out) - produced, len(self._buf))\n        if spill:\n            out[produced:produced+spill] = np.frombuffer(self._buf[:spill], dtype=np.uint8)\n            produced += spill\n            self._abs_out += spill\n            del self._buf[:spill]\n\n        self.consume(0, consumed)\n        return produced\n\n"
    len_tag_key: '"packet_len"'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_0_4
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_6, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', epy_block_5, '0']
- [epy_block_1, '0', blocks_file_sink_0_0_0_0, '0']
- [epy_block_1, '0', epy_block_4, '0']
- [epy_block_1, '0', epy_block_5_0, '0']
- [epy_block_2, '0', blocks_file_sink_0_1, '0']
- [epy_block_2, '0', epy_block_3, '0']
- [epy_block_2, '0', epy_block_5_2, '0']
- [epy_block_3, '0', blocks_file_sink_0_0_0_2, '0']
- [epy_block_3, '0', blocks_throttle2_0, '0']
- [epy_block_3, '0', epy_block_5_3, '0']
- [epy_block_4, '0', blocks_file_sink_0_0_0, '0']
- [epy_block_4, '0', epy_block_2, '0']
- [epy_block_4, '0', epy_block_5_1, '0']
- [epy_block_5, '0', qtgui_number_sink_0_0, '0']
- [epy_block_5_0, '0', qtgui_number_sink_0_1, '0']
- [epy_block_5_1, '0', qtgui_number_sink_0_2, '0']
- [epy_block_5_2, '0', qtgui_number_sink_0_3, '0']
- [epy_block_5_3, '0', qtgui_number_sink_0_4, '0']
- [epy_block_5_4, '0', qtgui_number_sink_0, '0']
- [epy_block_6, '0', blocks_file_sink_0_0_1, '0']
- [epy_block_6, '0', epy_block_0, '0']
- [epy_block_6, '0', epy_block_5_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
